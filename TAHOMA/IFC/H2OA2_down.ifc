Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: bf6fcfd4-86e1-419b-8f9d-58686fe872b4, NumberOfSaves: 1]
File name: Numéro de projet
Time: 2023-06-28T14:28:10+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.4.427 (FRA) - IFC 24.0.4.427

# IfcProject, Numéro de projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Autre - Adresse du projet: N° rueVille, Etat Code postal; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro de projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Adresse du projet: N° rueVille, Etat Code postal; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro de projet

# IfcBuildingStorey: Niveau:Pointe 8 mm (2)
Autre - Catégorie: Niveaux; Famille: Niveau; Famille et type: Niveau: Pointe 8 mm; ID du type: 27; Type: Pointe 8 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Référence de l'élévation: Point de base du projet
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: M_Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Name | LongName = Nom | Elevation (mm) = Elévation (mm)
Niveau 1 | Niveau 1 | 0
Niveau 2 | Niveau 2 | 4000

# IfcBuildingElementProxy: Famille2:Norme, Famille2:Norme:217535
In: Niveau 1
Type - Material: 0_0_0(13)
Type - Autre - Catégorie: Modèles génériques; Nom de la famille: Famille2
Type - Propriétés du modèle - Approbateur: none; Auteur: none; Concepteur: fpigot; Date de création: 28/06/2023; État de la conception: 1; Numéro de pièce: H2OA2_down; Numéro de révision: ANY; Preprocessor: CATIA Version 5-6 Release 2019; Sending System: 3DEXPERIENCE Platform STEP AP214 v1; Société: none; Titre: F:\Eurocave clim Juin 2023\H2OA2_down.stp
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: Norme
Pset_BuildingElementProxyCommon - Reference: Norme; sets with these values: 2
Autre - Famille: Famille2; Famille et type: Famille2: Norme; ID du type: 217520; Type: Norme
Contraintes - Décalage par rapport à l'hôte: 0 mm; Élévation par rapport au niveau: 0 mm; Hôte: Aucun(e); Se déplace avec les éléments voisins: no
Cotes - Surface: 1.31817 m2; Volume: 0.00530776 m3
Phase de construction - Phase de création: Nouvelle construction
